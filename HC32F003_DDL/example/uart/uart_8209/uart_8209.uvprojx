# Keil uVision project uart_8209.uvprojx, settings and files
target uart_8209 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F003C4PA HDSC
  pack: HDSC.HC32F003.1.0.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_8209 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\mcu\common;.\source;..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group common
    ./: startup_hc32f003.s
    ../../../mcu/common/: system_hc32f003.c
  group source
    ./source/: main.c rn8209.c alg.c led.c uart_test.c btimer.c uart_host.c
  group driver
    ../../../driver/src/: clk.c bt.c ddl.c interrupts_hc32f003.c uart.c gpio.c
software components: CMSIS:CORE 5.1.1
